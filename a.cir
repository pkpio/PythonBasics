r1 A D 2
r2 A B 1
r3 C D 3
v1 D C 1v dc
